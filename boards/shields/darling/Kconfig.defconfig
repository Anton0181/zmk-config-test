## boards/shields/darling/Kconfig.defconfig
```kconfig
if SHIELD_DARLING

config ZMK_KEYBOARD_NAME
    default "darling"

endif # SHIELD_DARLING
```
